inherit qtquickcompiler

PACKAGECONFIG = "lipi-toolkit lang-all hunspell"
