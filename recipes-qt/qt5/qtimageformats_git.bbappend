PACKAGECONFIG += "jasper libtiff libwebp"
