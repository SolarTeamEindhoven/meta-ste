FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

#SRC_URI += "file://0001-Remove-xkbcommon-evdev-dependecy.patch"
