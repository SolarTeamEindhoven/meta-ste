PACKAGECONFIG += "system-assimp"
