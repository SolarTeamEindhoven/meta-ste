FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "\
    file://0001-Support-class-names-not-stating-with-capital-Q.patch \
"
