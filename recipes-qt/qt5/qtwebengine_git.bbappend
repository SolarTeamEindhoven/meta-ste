PACKAGECONFIG += "opus icu ffmpeg libwebp libwebp flac libevent speex vpx"
