#PACKAGECONFIG += "qtwebkit"
PACKAGECONFIG_class-native ??= ""
PACKAGECONFIG_class-nativesdk ??= ""
