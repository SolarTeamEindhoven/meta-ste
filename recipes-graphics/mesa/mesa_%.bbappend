PROVIDES += "virtual/libgles3"
